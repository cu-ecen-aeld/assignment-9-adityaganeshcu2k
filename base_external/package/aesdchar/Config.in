## base_external/package/aesdchar/Config.in
```kconfig
config BR2_PACKAGE_AESDCHAR
    bool "aesd-char"
    help
      Includes the aesd-char device in kernel
```
